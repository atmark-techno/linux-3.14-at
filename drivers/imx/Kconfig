## drivers/imx/Kconfig
```kconfig
# drivers/imx/Kconfig

if ARCH_MXC

menu "IMX support drivers"
source "drivers/imx/adc/Kconfig"
endmenu

endif
```
